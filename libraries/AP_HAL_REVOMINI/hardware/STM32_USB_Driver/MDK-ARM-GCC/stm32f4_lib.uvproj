# Keil uVision project stm32f4_lib.uvproj, settings and files
target USB_Library (ARM-GNU)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32usb_lib (library)
  group src
    ../: usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_core.c usbd_ioreq.c usbd_req.c
  group inc
    ../: usb_bsp.h usb_conf.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h usbd_cdc_core.h usbd_conf.h usbd_core.h usbd_def.h usbd_desc.h usbd_ioreq.h usbd_req.h usbd_usr.h
